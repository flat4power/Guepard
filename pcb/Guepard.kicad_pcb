# Repository flat4power/Guepard (continued)

## KiCad design pcb/Guepard.kicad_pcb (continued)

Parts:
C25, C41, C49: 0.1uF
C39: 4.7uF
C40, C46: 1uF
D5, D18, D19: LED
D24: BLUE
D25: GREEN
J1: USB_B-micro
JP2: JUMPER
K2: CONN_3
L1: 40
R12: 4.7k
R16: 120
R17: 2.4k
R36, R47, R48: 330
R41, R42: 470
U7: MCP2551
U8: LM2937ES-3.3
U16: FT232RL
U17: HC-05
U18: ADUMX201
U19: ADUMX201

Connections:
5vdc: C25.2, C40.1, U7.3 (Vdd), U8.1, U18.1, U19.1; also elsewhere on the board
+3.3V: C46.1, R36.1, U8.3, U17.12 (3.3V), U19.8
/Communication/USB-5v: C39.1, C49.1, L1.2, R17.1, R41.2, R42.1, U16.4 (VCCIO), U16.20 (VCC), U18.8
/Communication/USB-GND: C39.2, C41.2, C49.2, J1.5 (GND), U16.7 (GND), U16.18 (GND), U16.21 (GND), U16.25 (AGND), U16.26 (TEST), U18.5
CPU-RXCAN0: U7.4 (RXD); also elsewhere on the board
CPU-RXD0: U18.2; also elsewhere on the board
CPU-RXD1: U19.2; also elsewhere on the board
CPU-TXCAN0: U7.1 (TXD); also elsewhere on the board
CPU-TXD0: U18.3; also elsewhere on the board
CPU-TXD1: U19.3; also elsewhere on the board
GROUND: C25.1, C40.2, C46.2, D5.2 (K), D24.2 (K), D25.2 (K), K2.2 (PM), R12.2, U7.2 (Vss), U8.2, U17.13 (GND), U17.34 (PIO11), U18.4, U19.4, U19.5; also elsewhere on the board
unnamed: R17.2, U16.19 (_RESET)
unnamed: C41.1, U16.17 (3V3OUT)
unnamed: J1.2 (D-), U16.16 (USBDM)
unnamed: U17.1 (UART-TXD), U19.7
unnamed: U17.2 (UART-RXD), U19.6
unnamed: U16.1 (TXD), U18.7
unnamed: J1.3 (D+), U16.15 (USBDP)
unnamed: D19.2 (K), U16.22 (CBUS1)
unnamed: U16.5 (RXD), U18.6
unnamed: D25.1 (A), R48.2
unnamed: D24.1 (A), R47.2
unnamed: D18.2 (K), U16.23 (CBUS0)
unnamed: JP2.2, R16.1
unnamed: J1.1 (Vbus), L1.1
unnamed: D5.1 (A), R36.2
unnamed: K2.3, R16.2, U7.6 (CANL)
unnamed: R12.1, U7.8 (Rs)
unnamed: R48.1, U17.32 (PIO9)
unnamed: R47.1, U17.31 (PIO8)
unnamed: D19.1 (A), R42.2
unnamed: JP2.1, K2.1, U7.7 (CANH)
unnamed: D18.1 (A), R41.1

Notes on the sheet:
CAN
USB
BLUETOOTH
R1 is optionnal populate if needed

Parts:
D3, D22, D28, D29: 1N5818-TP
D23, D32: ZENER 4.7V
P4, P5: CONN_1
R15, R39, R40, R45: 1k

Connections:
5vdc: D3.2 (K), D28.2 (K); also elsewhere on the board
GROUND: D22.1 (A), D23.1 (A), D29.1 (A), D32.1 (A); also elsewhere on the board
unnamed: D3.1 (A), D22.2 (K), D23.2 (K), R15.2, R39.1
unnamed: D28.1 (A), D29.2 (K), D32.2 (K), R40.2, R45.1
unnamed: P5.1, R40.1
unnamed: P4.1, R15.1
Spare-DIN-1: R39.2; also elsewhere on the board
Spare-DIN-2: R45.2; also elsewhere on the board

Notes on the sheet:
Spare Digital 2
All inputs 12V capable
Spare Digital 1
Connect P4 to P2 for Spare Digital 1 Connect P5 to P3 for Spare Digital 2

Board: 2 copper layers, 202 parts (0 on the bottom side), 136 nets.

## KiCad design communication/pcb/Guepard-Communication.kicad_pcb

Parts:
C1, C3, C6: 0.1uF
C2: 4.7uF
C4, C5: 1uF
C7: 0.1uF
D2, D3, D9: LED
D4: BLUE
D5: GREEN
J1: USB_B-micro
JP1: JUMPER
K1: CONN_3
L1: 40
P1, P2, P3, P4, P5, P6, P7, P8, P9, P10: CONN_1
P11: BATT1
Q1: MOS_N
R1: 2.4k
R2, R3: 470
R4, R5, R9: 330
R6, R7, R8: 10k
R10: 4.7k
R11: 120
U1: FT232RL
U2: ADUMX201
U3: HC-05
U4: LM2937ES-3.3
U5: MCP2551
U6: M41T56M6
X1: 32.768kHz

Connections:
+3.3V: Q1.1 (G), R8.1
/+5v: C4.1, C6.2, C7.1, P1.1, R6.1, U2.1, U4.1, U5.3 (Vdd), U6.8 (Vcc)
/USB-5v: C1.1, C2.1, L1.2, R1.1, R2.2, R3.1, U1.4 (VCCIO), U1.20 (VCC), U2.8
/USB-GND: C1.2, C2.2, U2.5
GND: C4.2, C5.2, C6.1, C7.2, D4.2 (K), D5.2 (K), D9.2 (K), K1.2 (PM), P2.1, P11.1, R10.2, U2.4, U3.13 (GND), U3.34 (PIO11), U4.2, U5.2 (Vss), U6.4 (Vss)
unnamed: J1.1 (Vbus), L1.1
unnamed: Q1.2 (S), R8.2, U3.1 (UART-TXD)
unnamed: D4.1 (A), R4.2
unnamed: R4.1, U3.31 (PIO8)
unnamed: D5.1 (A), R5.2
unnamed: R5.1, U3.32 (PIO9)
unnamed: R7.2, U3.2 (UART-RXD)
unnamed: P5.1, R7.1
unnamed: P3.1, U2.2
unnamed: P4.1, U2.3
unnamed: D3.1 (A), R3.2
unnamed: D2.1 (A), R2.1
unnamed: D3.2 (K), U1.22 (CBUS1)
unnamed: P11.2 (PM), U6.3 (VBAT)
unnamed: U6.1 (OSCI), X1.2
unnamed: U6.2 (OSCO), X1.1
unnamed: P10.1, U6.6 (SCL)
unnamed: P9.1, U6.5 (SDA)
unnamed: R1.2, U1.19 (RESET)
unnamed: U1.1 (TXD), U2.7
unnamed: C3.1, U1.17 (3V3OUT)
unnamed: J1.2 (D-), U1.16 (USBD-)
unnamed: J1.3 (D+), U1.15 (USBD+)
unnamed: D2.2 (K), U1.23 (CBUS0)
unnamed: C3.2, J1.5 (GND), U1.7 (GND), U1.18 (GND), U1.21 (GND), U1.25 (AGND), U1.26 (TEST)
unnamed: U1.5 (RXD), U2.6
unnamed: P6.1, Q1.3 (D), R6.2
unnamed: P7.1, U5.4 (RXD)
unnamed: JP1.2, R11.1
unnamed: D9.1 (A), R9.2
unnamed: R10.1, U5.8 (Rs)
unnamed: P8.1, U5.1 (TXD)
unnamed: K1.3, R11.2, U5.6 (CANL)
unnamed: JP1.1, K1.1, U5.7 (CANH)
unnamed: C5.1, R9.1, U3.12 (3.3V), U4.3

Notes on the sheet:
CAN
USB
BLUETOOTH
R1 is optionnal populate if needed
RTC

Board: 2 copper layers, 45 parts (0 on the bottom side), 38 nets, no tracks yet.

## Commit log

2013-05-16 schematics
2013-05-23 full update
2013-05-28 change MAT to SPR input
2013-05-28 Change CEL/Load Circuit (add a R10 1k resistor)
2013-05-28 replace TC442xa with TC4427
2013-05-28 LICENSE.txt
2013-05-28 Communication Board
2013-06-19 delete communication board
    communication circuit nox include on main board
2013-06-19 schematics update
2013-06-19 communication update and PCB
2013-06-19 docs and library
2013-06-19 deleted
2013-06-19 MPX4250 footprint
2013-06-27 replace M41T56M6 by DS1307ZN+
    remove keystone103 for RTC battery and replace it by 2 pin
    change MCP2551 soic8 to DIP8
2013-06-27 Ground plane under MCU - RPM traces - power capacitor for MCU
    The ground plane under the Freescale MCU should look like the suggested
    PCB design in the Freescale 9S12XDP512 datasheet
2013-07-02 deleted .bak
2013-07-02 bluetooth level converter ADUM3201
2013-07-02 general update
