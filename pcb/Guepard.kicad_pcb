# Repository flat4power/Guepard

File README.md:

Guepard
=======

Guepard board for FreeEMS

## KiCad design pcb/Guepard.kicad_pcb

Parts:
J5: TE-776163

Connections:
+12V-ACC: J5.9 (+12V-ACC); also elsewhere on the board
+12V-SWITCH: J5.10 (+12V-SWITCH); also elsewhere on the board
Coolant-Sensor: J5.28 (Coolant); also elsewhere on the board
FP-Relay: J5.18 (FP-Relay); also elsewhere on the board
GROUND: J5.2 (Sensor-GND), J5.3 (Sensor-GND), J5.4 (Sensor-GND), J5.21 (GROUND), J5.22 (GROUND); also elsewhere on the board
IAT-Sensor: J5.17 (IAT); also elsewhere on the board
Ignitor1: J5.35 (Ignitor1); also elsewhere on the board
Ignitor2: J5.23 (Ignitor2); also elsewhere on the board
Ignitor3: J5.11 (Ignitor3); also elsewhere on the board
Ignitor4: J5.12 (Ignitor4); also elsewhere on the board
Injector1/3: J5.33 (Injector1/3); also elsewhere on the board
Injector2/4: J5.32 (Injector2/4); also elsewhere on the board
Injector-GND: J5.31 (INJ-GND), J5.34 (INJ-GND); also elsewhere on the board
O2-Sensor: J5.27 (O2); also elsewhere on the board
Output-Ground: J5.8 (Output-GND), J5.19 (Output-GND), J5.20 (Output-GND); also elsewhere on the board
RPM-Crank-IN+: J5.1 (CRANK+); also elsewhere on the board
RPM-Crank-IN-: J5.13 (CRANK-); also elsewhere on the board
SPR-Sensor: J5.15 (SPR-Sensor); also elsewhere on the board
Spare-DIN-1: J5.14 (Spare-Din-1); also elsewhere on the board
Spare-DIN-2: J5.25 (Spare-DIN-2); also elsewhere on the board
Spare-LSD-1: J5.29 (Spare-LSD-1); also elsewhere on the board
Spare-LSD-2: J5.30 (Spare-LSD-2); also elsewhere on the board
TPS-Sensor: J5.16 (TPS); also elsewhere on the board

Notes on the sheet:
12v-Constant

Parts:
C20, C27, C31, C36, C37, C38, C55: 0.22uF
C21, C56: 0.33uF
C22, C26, C29, C32, C33, C34, C35, C54: 0.1uF
C23, C42, C53: 0.01uF
C24: 1nF
C28: 0.1uF(+10V)
C30: 0.22uF(+35V)
C43: 1uF
D4: LED
D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: 1N5818-TP
R9: 2.4k
R11: 10k
R13, R26, R27, R28, R32, R33, R34, R95: 470
R18, R19, R22, R30, R80, R83: 1k
R23: 5.1k
R24, R25, R31: 2.49k
R29: 3.9k
U4: MAX9926UAEE+
U6: MPX4250AP
U11: MPXA6115AC6U

Connections:
5vdc: C21.2, C23.2, C26.2, C42.2, C43.2, C53.2, C56.2, D4.1 (A), D6.2 (K), D8.2 (K), D10.2 (K), D12.2 (K), D14.2 (K), D16.2 (K), R11.1, R22.1, R24.1, R25.1, R31.1, R83.2, U4.14 (VCC), U6.3 (Vs), U11.2 (Vin); also elsewhere on the board
+12V-ACC: R29.1; also elsewhere on the board
AAP: C55.1, R95.2; also elsewhere on the board
BRV: C27.2, D6.1 (A), D7.2 (K), R28.2; also elsewhere on the board
COOLANT: C36.1, D12.1 (A), D13.2 (K), R32.1; also elsewhere on the board
Coolant-Sensor: C33.1, R31.2, R32.2; also elsewhere on the board
GROUND: C20.2, C21.1, C22.2, C23.1, C26.1, C27.1, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C42.1, C43.1, C53.1, C54.2, C55.2, C56.1, D7.1 (A), D9.1 (A), D11.1 (A), D13.1 (A), D15.1 (A), D17.1 (A), R30.2, U4.1 (INT_THRS1), U4.3 (BIAS1), U4.6 (BIAS2), U4.8 (IN_THRS2), U4.11 (GND), U4.13 (ZERO_EN), U6.2 (GND), U11.3 (GND); also elsewhere on the board
IAT: C31.1, D10.1 (A), D11.2 (K), R27.1; also elsewhere on the board
IAT-Sensor: C29.1, R25.2, R27.2; also elsewhere on the board
MAP: C20.1, R13.2; also elsewhere on the board
unnamed: C32.1, R28.1, R29.2, R30.1
unnamed: R9.2, R11.2, R80.1, U4.4 (COUT1)
unnamed: C24.1, R18.1, U4.16 (IN1+)
unnamed: C54.1, R95.1, U11.4 (Vout)
unnamed: C24.2, R19.1, R83.1, U4.15 (IN1-)
unnamed: D4.2 (K), R9.1
unnamed: C22.1, R13.1, U6.1 (Vout)
O2: C38.1, D16.1 (A), D17.2 (K), R33.1; also elsewhere on the board
O2-Sensor: C34.1, R33.2; also elsewhere on the board
RPM0: R80.2; also elsewhere on the board
RPM-Crank-IN+: R18.2, R22.2, R23.1; also elsewhere on the board
RPM-Crank-IN-: R19.2, R23.2; also elsewhere on the board
SPR: C30.1, D8.1 (A), D9.2 (K), R26.1; also elsewhere on the board
SPR-Sensor: C28.1, R24.2, R26.2; also elsewhere on the board
TPS: C37.1, D14.1 (A), D15.2 (K), R34.1; also elsewhere on the board
TPS-Sensor: C35.1, R34.2; also elsewhere on the board

Notes on the sheet:
For GM DIS and Ford EDIS connect RPM0-IN- and RPM1-IN- to ground. For Ford EDIS do not connect RPM1-IN+ to anything either. R16, R17, C25, R10, R12 and D5 are not needed for the EDIS system. R20 and 23 are only to be used with VR Inputs, do not populate these components for GM DIS or Ford EDIS syst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
C34 is +35V and C38 is +10V
C32 is +35V and C27 is +10V
C53, C54, C56 and C57 are +10V
Ambient Absolute Pressure
CPU Pin 77
Change R18 and R19 to 10k for VR Input ONLY.
Connect RPM0-IN- to GND for Hall/Opto/Digital
Do not populate C23 and C21 if you are using an external MAP sensor. Change R13 value from 1k to 470 ohm if you are using an external MAP sensor.
D47 and D48 are only populated if you are using an external MAP sensor. Do not populate these locations if you are using the on-board sensor.
Exhaust Oxygen Sensor
CPU Pin 73
R24, R25 and R31 (2.49k) can be replaced if using sensors other than GM temperature sensors; For FORD Sensors: use 27.4k 0.1% Metal Film resistors; for MOPAR Sensors: use 9.1k 0.1% Metal Film resistors or use 2.43k 0.1% Metal Film resistors (best for most cases). Be sure to use FreeTherm to adjust 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
D4/R9 and D5/R10 are For Diagnostics Only! If they cause issues, remove them.
R23 can be any resistance between 100 ohm and 10k ohm 2W to 5W for VR Input ONLY.
NOTE: MAX9926 should be configured as Mode A2 for both VR and Hall/Opto/Digital inputs. RPM0-IN- and RPM1-IN- should be held at 2.5vdc for Hall/Opto/Digital inputs. R16, R84. R19 and R83 accomplish this by setting up a voltage divider circuit. For VR inputs, R18, R19, R16 and R17 need to be 10k res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
This jumper allows us to jump over Vcc on the PCB
R22 Pullup Resistor for Hall/Opto/Digital Inputs Only. Do NOT populate for VR Input.
Crankshaft and Camshaft Inputs
CPU Pin 75
CPU Pin 69
CPU Pin 67
CPU Pin 71
CPU Pin 81
CPU Pin 79
Coolant Temperature
Intake Air Temperature
Throttle Position Sensor
Spare ADC Input
Manifold Absolute Pressure
Battery Reference Voltage

Parts:
C52, C57: 1uF
D30, D37, D39, D41, D49, D50, D51: LED
D31, D40, D42: 1N4148
JP11: 5v/12v
Q9, Q10, Q11: VNN7NV0413TR
R53, R72, R75: 2.4k
R54, R74, R77, R87, R88, R104, R105: 1k
R63, R73, R76, R89, R90, R102, R103: 100k
R65, R66, R67, R68: 2k4
R91, R92, R100, R101: 160
U9, U12: TC4427AVOA

Connections:
5vdc: JP11.3; also elsewhere on the board
+12V-SWITCH: JP11.1, R53.2, R72.2, R75.2; also elsewhere on the board
FP-Relay: D31.2 (K), Q9.D; also elsewhere on the board
Fuel-Pump-Drive: R54.2, R63.1; also elsewhere on the board
GROUND: C52.2, C57.2, D37.2 (K), D49.2 (K), D50.2 (K), D51.2 (K), R63.2, R73.2, R76.2, R89.2, R90.2, R102.2, R103.2, U9.3, U12.3; also elsewhere on the board
Ignitor1: R91.2; also elsewhere on the board
Ignitor1-IN: R88.1, R90.1; also elsewhere on the board
Ignitor2: R92.1; also elsewhere on the board
Ignitor2-IN: R87.1, R89.1; also elsewhere on the board
Ignitor3: R100.2; also elsewhere on the board
Ignitor3-IN: R102.1, R104.1; also elsewhere on the board
Ignitor4: R101.1; also elsewhere on the board
Ignitor4-IN: R103.1, R105.1; also elsewhere on the board
unnamed: Q11.G, R77.1
unnamed: Q9.G, R54.1
unnamed: Q10.G, R74.1
unnamed: R105.2, U12.4
unnamed: R66.1, R92.2, U9.5
unnamed: R67.1, R100.1, U12.7
unnamed: R68.1, R101.2, U12.5
unnamed: C52.1, C57.1, JP11.2 (PM), U9.6, U12.6
unnamed: R65.1, R91.1, U9.7
unnamed: R104.2, U12.2
unnamed: D41.1 (A), R75.1
unnamed: D41.2 (K), D42.1 (A)
unnamed: R88.2, U9.2
unnamed: R87.2, U9.4
unnamed: D30.2 (K), D31.1 (A)
unnamed: D30.1 (A), R53.1
unnamed: D39.1 (A), R72.1
unnamed: D39.2 (K), D40.1 (A)
unnamed: D37.1 (A), R65.2
unnamed: D49.1 (A), R66.2
unnamed: D51.1 (A), R68.2
unnamed: D50.1 (A), R67.2
Output-Ground: Q9.S, Q10.S, Q11.S; also elsewhere on the board
PP3: R73.1, R74.2; also elsewhere on the board
PP5: R76.1, R77.2; also elsewhere on the board
Spare-LSD-1: D40.2 (K), Q10.D; also elsewhere on the board
Spare-LSD-2: D42.2 (K), Q11.D; also elsewhere on the board

Notes on the sheet:
Ignitor Outputs
JP11 selects either 5v or 12v Driver IC Supply
Low Side Driver #2 Output
Low Side Driver #1 Output
Fuel Pump Relay Output

Parts:
D20, D21: LED
D26, D27: 1N4148
Q3, Q4: VND14NV04
R37, R38: 100k
R43, R44: 1k; Digikey 1.00KXBK-ND
R49, R50: 2.4k

Connections:
+12V-SWITCH: R49.2, R50.2; also elsewhere on the board
GROUND: R37.2, R38.2; also elsewhere on the board
Injector1/3: D26.2 (K), Q3.D; also elsewhere on the board
Injector1/3-IN: R37.1, R43.2; also elsewhere on the board
Injector2/4: D27.2 (K), Q4.D; also elsewhere on the board
Injector2/4-IN: R38.1, R44.2; also elsewhere on the board
Injector-GND: Q3.S, Q4.S; also elsewhere on the board
unnamed: Q3.G, R43.1
unnamed: Q4.G, R44.1
unnamed: D20.2 (K), D26.1 (A)
unnamed: D20.1 (A), R49.1
unnamed: D21.2 (K), D27.1 (A)
unnamed: D21.1 (A), R50.1

Parts:
C13: 10uF
C15, C17: 0.1uF
C19: 47uF
D2: 5.6V 3W
D36: +5VLED
D44: 1N5818-TP
MOV1: ERZ-V14D220
R56: 2k4
U3: LM2940T-5.0

Connections:
5vdc: C17.1, C19.1, D2.2 (K), R56.1, U3.3; also elsewhere on the board
+12V-SWITCH: D44.1 (A), MOV1.1; also elsewhere on the board
GROUND: C13.2, C15.2, C17.2, C19.2, D2.1 (A), D36.2 (K), MOV1.2, U3.2; also elsewhere on the board
unnamed: D36.1 (A), R56.2
unnamed: C13.1, C15.1, D44.2 (K), U3.1

Notes on the sheet:
C15 and C17 are 50v X7R Ceramic capacitors.
C13 is 35v Tantalum capacitors. C19 is 10v Tantalum capacitors.

Parts:
C1, C2, C3, C4, C5, C8, C44: 0.22uF
C6, C45: 0.1uF
C7: 6.8nF
C9: 680pF
C10, C11: 20pF
C47, C48: 10uF
D1: CEL
JP1: JUMPER
P2, P3: CONN_1
P9: BATT1
P27: BDM
R1, R2, R3, R4, R5: 10k
R6: 3.3k
R8, R10: 1k
R14: 2k4
U1: MC9S12XDP512; mc9s12xdp512-LQFP112
U5: DS1307ZN+
X1: 16MHz
X2: 32.768kHz

Connections:
5vdc: C2.1, C3.2, C4.1, C44.2, C45.1, C47.1, C48.1, D1.1 (A), P27.6, R1.2, R4.2, R5.2, R14.1, U1.41 (VDDR1), U1.83 (VDDA), U1.84 (VRH), U1.97 (VREGEN), U1.107 (VDDX), U5.8 (Vcc); also elsewhere on the board
/CPU/BKGD: P27.1, R4.1, U1.23 (MODC_BKGD)
/CPU/RESET: C6.1, P27.4, R5.1, U1.42 (/RESET)
AAP: U1.77 (PAD05_AN05); also elsewhere on the board
BRV: U1.79 (PAD06_AN06); also elsewhere on the board
COOLANT: U1.69 (PAD01_AN01); also elsewhere on the board
CPU-RXCAN0: U1.105 (PM0_RXCAN0); also elsewhere on the board
CPU-RXD0: U1.89 (PS0_RXD0); also elsewhere on the board
CPU-RXD1: U1.91 (PS2_RXD1); also elsewhere on the board
CPU-TXCAN0: U1.104 (PM1_TXCAN0); also elsewhere on the board
CPU-TXD0: U1.90 (PS1_TXD0); also elsewhere on the board
CPU-TXD1: U1.92 (PS3_TXD1); also elsewhere on the board
EXTAL: C10.2, U1.46 (EXTAL), X1.1
Fuel-Pump-Drive: U1.64 (PA7); also elsewhere on the board
GROUND: C1.1, C2.2, C3.1, C4.2, C5.1, C6.2, C8.1, C10.1, C11.1, C44.1, C45.2, C47.2, C48.2, JP1.1, P9.1, P27.2, R2.2, R3.2, U1.14 (VSS1), U1.40 (VSSR1), U1.45 (VSSPLL), U1.48 (TEST), U1.66 (VSS2), U1.85 (VRL), U1.86 (VSSA), U1.106 (VSSX), U5.4 (Vss); also elsewhere on the board
IAT: U1.67 (PAD00_AN00); also elsewhere on the board
Ignitor1-IN: U1.11 (IOC2_PT2); also elsewhere on the board
Ignitor2-IN: U1.12 (IOC3_PT3); also elsewhere on the board
Ignitor3-IN: U1.15 (IOC3_PT4); also elsewhere on the board
Ignitor4-IN: U1.16 (IOC5_PT5); also elsewhere on the board
Injector1/3-IN: U1.17 (IOC6_PT6); also elsewhere on the board
Injector2/4-IN: U1.18 (IOC7_PT7); also elsewhere on the board
LOAD: R10.1, U1.63 (PA6)
MAP: U1.75 (PAD04_AN04); also elsewhere on the board
unnamed: C1.2, U1.13 (VDD1)
unnamed: R2.1, U1.37 (MODB_PE6)
unnamed: U5.1 (OSCI), X2.2
unnamed: P9.2 (PM), U5.3 (VBAT)
unnamed: P3.1, U1.21 (TXD2_KWJ1_PJ1)
unnamed: R3.1, U1.38 (MODA_PE5)
unnamed: R1.1, U1.36 (/XCLK_PE7)
unnamed: C7.1, R6.1
unnamed: P2.1, U1.22 (RXD2_KWJ0_PJ0)
unnamed: U5.2 (OSCO), X2.1
unnamed: C5.2, U1.65 (VDD2)
unnamed: D1.2 (K), R8.1
unnamed: JP1.2, R8.2, R10.2, R14.2
O2: U1.73 (PAD03_AN03); also elsewhere on the board
PJ6: U1.99 (PJ6_KWJ6_RXCAN4_SDA0_RXCAN0), U5.5 (SDA)
PJ7: U1.98 (PJ7_KWJ7_TXCAN4_SCL0_TXCAN0), U5.6 (SCL)
PP3: U1.1 (/SS1_PWM3_KWP3_PP3); also elsewhere on the board
PP5: U1.111 (PP5_KPW5_PWM5_MOSI2); also elsewhere on the board
RPM0: U1.9 (IOC0_PT0); also elsewhere on the board
SPR: U1.81 (PAD07_AN07); also elsewhere on the board
TPS: U1.71 (PAD02_AN02); also elsewhere on the board
VDDPLL: C7.2, C8.2, C9.2, U1.43 (VDDPLL)
XFC: C9.1, R6.2, U1.44 (XFC)
XTAL: C11.2, U1.47 (XTAL), X1.2

Notes on the sheet:
Note: R8 is set to 1k to compliment the R14 2k4 next to it and provide a strong initial pull-up. Until the LED drop renders it inactive. This also allow the CEL LED to be brigther.
Firmware Load Jumper
Serial Monitor
RTC Circuit
CPU Pin 45
CPU Pin 44
CPU Pin 43
PP1 and PP2 allow us access to the Port P0-7 pins on the CPU so that we can test these outputs in the future.
C4 and C44 X7R Ceramic
C48 10v Tantalum C3 X7R Ceramic
C47 10v Tantalum C2 X7R Ceramic
C1 X7R Ceramic
C5 X7R Ceramic
XCLK
MODB
MODA
Crystal Circuit
PLL Circuit
BDM Connector
Connect P2 to P4 for Spare Digital 1 Connect P3 to P5 for Spare Digital 2
